<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/generic_CC1352P.ewp</path>
  </project>
  <batchBuild/>
</workspace>
